
IMAGE_FSTYPES += "ext4"
IMAGE_INSTALL += "mmdc"
